options:
  parameters:
    generate_options: qt_gui
    id: ISM
    output_language: python
    title: ISM receiver
  states: {}

blocks:
- name: Gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: Gain1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: Gain
  states: {}
- name: bandwith
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: bandwith1
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: '1'
    stop: 3e6
    value: bandwith
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 2.3e9
    step: '1'
    stop: 2.6e9
    value: freq
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: LNAW
    args: soapy=0,driver=lime
    bb_gain0: '20'
    freq0: frequency
    gain0: Gain1
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: bandwith1
    comment: Plot FFT over frequency.
    ctrlpanel: 'True'
    fc: frequency
    fftsize: '1024'
    grid: 'True'
    name: FFT over frequency
    showports: 'True'
    type: complex
    ymax: '30'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bandwith1
    color1: '2'
    comment: Plot FFT over time.
    fc: frequency
    fftsize: '1024'
    gui_hint: (1,0,1,1)
    int_max: '30'
    name: FFT over Time
    showports: 'True'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
