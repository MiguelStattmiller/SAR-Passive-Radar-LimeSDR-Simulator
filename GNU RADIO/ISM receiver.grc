options:
  parameters:
    author: YAKOTT
    description: Analizador de Espectro Radioeléctrico en el rango de 325 MHz a 3800 MHz
    generate_options: qt_gui
    id: QT_PlutoSDR_Spectrum_Analyzer
    output_language: python
    title: QT_PlutoSDR_Spectrum_Analyzer
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    comment: Plot FFT over frequency.
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    grid: 'True'
    name: FFT over frequency
    showports: 'True'
    type: complex
    ymax: '30'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Plot FFT over time.
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: (1,0,1,1)
    int_max: '30'
    name: FFT over Time
    showports: 'True'
    type: complex
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    dev_args: soapy=0,driver=lime
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
